SRC_URI="git://github.com/jack2015/skin-PLiHD.git;protocol=git"
